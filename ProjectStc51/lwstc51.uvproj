# Keil uVision project lwstc51.uvproj, settings and files
target lwstc51 (MCS-51)
  device: AT89C55 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: lwstc51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Library\lw
  group user
    ../user/: main.c res.h

# Keil uVision project LWMS51.uvproj, settings and files
target LWMS51 (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: LWMS51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000,MS51
  c include: ..\Library\Nuvoton\MS51;..\Library\Nuvoton\MS51\StdDriver\inc;..\Library\lw;
  group Startup
    ../Library/Nuvoton/MS51/: STARTUP.A51
  group User
    ../user/: main.c res.h res_color_pic.h
